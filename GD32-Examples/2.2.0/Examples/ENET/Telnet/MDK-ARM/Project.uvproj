# Keil uVision project Project.uvproj, settings and files
target GD32F4XX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F427ZG GigaDevice
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GD32427ZG
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\..\..\..\Firmware\GD32F4xx_standard_peripheral\Include;..\..\..\..\Utilities;..\inc;..\lwip-2.2.0\src\include;..\lwip-2.2.0\src\include\ipv4;..\lwip-2.2.0\src\include\netif;..\lwip-2.2.0\src\include\lwip;..\lwip-2.2.0\port\GD32F4xx;..\lwip-2.2.0\port\GD32F4xx\Basic;..\..\..\..\Firmware\CMSIS;..\..\..\..\Firmware\CMSIS\GD\GD32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: main.c gd32f4xx_it.c gd32f4xx_enet_eval.c netconf.c hello_gigadevice.c
  group GD32F4xx_Peripherals
    ../../../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Lwip
    ../lwip-2.2.0/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.2.0/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip-2.2.0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../lwip-2.2.0/src/netif/: ethernet.c
  group Lwip_apps
    ../lwip-2.2.0/src/apps/http/: fs.c httpd.c
  group Lwip_port
    ../lwip-2.2.0/port/GD32F4xx/Basic/: ethernetif.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../../../../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group GD32F4xx_BSP
    ../../../../Utilities/: gd32f427zg_bsp.c
  group Doc
    ../src/: readme.txt
